# Keil uVision project W5X00_STM32F411_Modbus.uvprojx, settings and files
target W5X00_STM32F411_Modbus (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: W5X00_STM32F411_Modbus +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Libraries/ioLibrary_Driver/Application/loopback;../Libraries/ioLibrary_Driver/Ethernet;../Libraries/ioLibrary_Driver/Ethernet/W5100S;../Libraries/ioLibrary_Driver/Ethernet/W5500;../Libraries/modbus;../port;../port/ioLibrary_Driver;../port/modbus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Libraries/ioLibrary
    ../Libraries/ioLibrary_Driver/Application/loopback/: loopback.c
    ../Libraries/ioLibrary_Driver/Ethernet/W5500/: w5500.c
    ../Libraries/ioLibrary_Driver/Ethernet/: socket.c wizchip_conf.c
    ../Libraries/ioLibrary_Driver/Ethernet/W5100S/: w5100s.c
  group port/ioLibrary_Driver
    ../port/ioLibrary_Driver/: w5x00_spi.c
  group Libraries/modbus
    ../Libraries/modbus/: mb.c mbascii.c mbcrc.c mbrtu.c mbtcp.c mbtimer.c
  group port/modbus
    ../port/modbus/: modbus_serial.c
software components: CMSIS:CORE 4.3.0
